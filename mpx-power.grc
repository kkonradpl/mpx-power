<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Konrad Kosmatka</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>FM MPX Power Monitor</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>280</value></param>
<param><key>label</key><value>Bandwidth [kHz]</value></param>
<param><key>max</key><value>(100 + 60) * 2</value></param>
<param><key>min</key><value>50</value></param>
<param><key>notebook</key><value>tabs,0</value></param>
<param><key>num_steps</key><value>(100 + 60) * 2 - 50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deemph</value></param>
<param><key>value</key><value>50e-6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>99200</value></param>
<param><key>label</key><value>Frequency [kHz]</value></param>
<param><key>max</key><value>108000</value></param>
<param><key>min</key><value>87000</value></param>
<param><key>notebook</key><value>tabs,0</value></param>
<param><key>num_steps</key><value>(108000-87000)/100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>((100 + 59) * 2 * 1000) / 2 + 6000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gen_dev</value></param>
<param><key>value</key><value>19000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_hold</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_taps</value></param>
<param><key>value</key><value>[0.0009182306239381433, -0.00025654269848018885, -0.0013555705081671476, -0.001962132751941681, -0.0018382493872195482, -0.0010178526863455772, 0.00020125597075093538, 0.0013654007343575358, 0.002033853903412819, 0.0019456685986369848, 0.001121374312788248, -0.00014003500109538436, -0.0013694431399926543, -0.0021020700223743916, -0.002053168136626482, -0.0012285460252314806, 7.292648660950363e-05, 0.0013675241498276591, 0.002166450023651123, 0.002160380594432354, 0.0013391001848503947, -1.1134821948207737e-18, -0.001359489164315164, -0.00222667190246284, -0.00226693507283926, -0.0014527522725984454, -7.865211955504492e-05, 0.0013452036073431373, 0.0022824229672551155, 0.002372455084696412, 0.0015692014712840319, 0.0001629147882340476, -0.0013245539739727974, -0.002333402168005705, -0.0024765627458691597, -0.0016881315968930721, -0.0002526503521949053, 0.0012974482960999012, 0.0023793214932084084, 0.0025788790080696344, 0.0018092120299115777, 0.00034769895137287676, -0.001263816375285387, -0.0024199059698730707, -0.0026790250558406115, -0.001932099461555481, -0.0004478787013795227, 0.0012236111797392368, 0.002454895991832018, 0.0027766244020313025, 0.0020564382430166006, 0.000552986457478255, -0.0011768086114898324, -0.002484048716723919, -0.002871304051950574, -0.0021818627137690783, -0.0006627980037592351, 0.001123407855629921, 0.0025071382988244295, 0.002962695434689522, 0.002307996852323413, 0.0007770691299811006, -0.0010634318459779024, -0.002523957286030054, -0.0030504364985972643, -0.0024344578851014376, -0.0008955357479862869, 0.000996927497908473, 0.0025343175511807203, 0.003134173573926091, 0.002560855122283101, 0.001017915434204042, -0.0009239654755219817, -0.002538051689043641, -0.003213561372831464, -0.002686793217435479, -0.0011439077788963914, 0.0008446403662674129, 0.0025350130163133144, 0.003288266249001026, 0.0028118735644966364, 0.0012731956085190177, -0.0007590703899040818, -0.0025250769685953856, -0.0033579657319933176, -0.0029356940649449825, -0.0014054457424208522, 0.0006673974567092955, 0.002508141566067934, 0.003422351088374853, 0.0030578530859202147, 0.0015403105644509196, -0.0005697865271940827, -0.0024841276463121176, -0.003481128253042698, -0.0031779485289007425, -0.0016774289542809129, 0.0004664254083763808, 0.002452980726957321, 0.003534019226208329, 0.0032955820206552744, 0.0018164274515584111, -0.00035752408439293504, -0.002414669143036008, -0.0035807627718895674, -0.0034103572834283113, -0.00195692153647542, 0.0002433142944937572, 0.002369186608120799, 0.003621115582063794, 0.003521884558722377, 0.0020985177252441645, -0.00012404864537529647, -0.002316551050171256, -0.0036548543721437454, -0.0036297801416367292, -0.0022408131044358015, 6.611300189243871e-18, 0.0022568050771951675, 0.0036817756481468678, 0.003733669174835086, 0.0023833992891013622, 0.00012853949738200754, -0.0021900166757404804, -0.00370169710367918, -0.003833186812698841, -0.0025258618406951427, -0.000261259323451668, 0.002116277813911438, 0.003714458318427205, 0.003927977290004492, 0.002667783061042428, 0.00039783157990314066, -0.0020357053726911545, -0.0037199221551418304, -0.00401770044118166, -0.0028087422251701355, -0.0005379121284931898, 0.001948440563865006, 0.003717973828315735, 0.004102027975022793, 0.0029483186081051826, 0.0006811417988501489, -0.001854648464359343, -0.003708523465320468, -0.004180646501481533, -0.0030860919505357742, -0.0008271473925560713, 0.0017545174341648817, 0.0036915054079145193, 0.004253261256963015, 0.0032216450199484825, 0.000975543400272727, -0.001648259349167347, -0.003666879143565893, -0.0043195937760174274, -0.0033545633777976036, -0.0011259327875450253, 0.0015361076220870018, 0.0036346286069601774, 0.004379383288323879, 0.0034844393376260996, 0.0012779090320691466, -0.0014183175517246127, -0.0035947635769844055, -0.004432390909641981, -0.0036108712665736675, -0.001431056996807456, 0.0012951655080541968, 0.0035473189782351255, 0.004478397313505411, 0.0037334668450057507, 0.0015849546762183309, -0.001166946836747229, -0.003492355812340975, -0.004517205059528351, -0.0038518430665135384, -0.0017391747096553445, 0.0010339765576645732, 0.0034299599938094616, 0.004548639990389347, 0.003965628333389759, 0.0018932860111817718, -0.0008965870947577059, -0.003360242350026965, -0.004572550766170025, -0.004074465483427048, -0.0020468549337238073, 0.0007551274029538035, 0.003283339086920023, 0.004588809795677662, 0.004178009927272797, 0.0021994474809616804, -0.0006099619786255062, -0.0031994106248021126, -0.004597314167767763, -0.004275932442396879, -0.0023506300058215857, 0.0004614694626070559, 0.003108641365543008, 0.004597986117005348, 0.0043679228983819485, 0.002499972004443407, -0.00031004135962575674, -0.003011238994076848, -0.004590773489326239, -0.004453686065971851, -0.0026470464654266834, 0.00015608056855853647, 0.002907434245571494, 0.004575648810714483, 0.004532947670668364, 0.0027914319653064013, -5.5674106639111386e-18, -0.0027974797412753105, -0.0045526111498475075, -0.004605453927069902, -0.002932714531198144, -0.00015777887892909348, 0.0026816485915333033, 0.004521685652434826, 0.004670972004532814, 0.0030704885721206665, 0.00031682755798101425, -0.002560234861448407, -0.004482922609895468, -0.004729289561510086, -0.0032043587416410446, -0.0004767120990436524, 0.002433551475405693, 0.0044363983906805515, 0.0047802189365029335, 0.0033339415676891804, 0.0006369944312609732, -0.0023019290529191494, -0.004382215905934572, -0.004823595751076937, -0.003458866151049733, -0.0007972343591973186, 0.0021657152101397514, 0.004320500884205103, 0.004859279375523329, 0.0035787762608379126, 0.0009569909307174385, -0.00202527386136353, -0.004251406062394381, -0.004887153394520283, -0.003693331265822053, -0.0011158237466588616, 0.0018809823086485267, 0.0041751074604690075, 0.004907128866761923, 0.003802207065746188, 0.001273295027203858, -0.001733231358230114, -0.004091804381459951, -0.004919140134006739, -0.0039050988852977753, -0.001428971067070961, 0.0015824235742911696, 0.00400172034278512, 0.004923148546367884, 0.00400172034278512, 0.0015824235742911696, -0.001428971067070961, -0.0039050988852977753, -0.004919140134006739, -0.004091804381459951, -0.001733231358230114, 0.001273295027203858, 0.003802207065746188, 0.004907128866761923, 0.0041751074604690075, 0.0018809823086485267, -0.0011158237466588616, -0.003693331265822053, -0.004887153394520283, -0.004251406062394381, -0.00202527386136353, 0.0009569909307174385, 0.0035787762608379126, 0.004859279375523329, 0.004320500884205103, 0.0021657152101397514, -0.0007972343591973186, -0.003458866151049733, -0.004823595751076937, -0.004382215905934572, -0.0023019290529191494, 0.0006369944312609732, 0.0033339415676891804, 0.0047802189365029335, 0.0044363983906805515, 0.002433551475405693, -0.0004767120990436524, -0.0032043587416410446, -0.004729289561510086, -0.004482922609895468, -0.002560234861448407, 0.00031682755798101425, 0.0030704885721206665, 0.004670972004532814, 0.004521685652434826, 0.0026816485915333033, -0.00015777887892909348, -0.002932714531198144, -0.004605453927069902, -0.0045526111498475075, -0.0027974797412753105, -5.5674106639111386e-18, 0.0027914319653064013, 0.004532947670668364, 0.004575648810714483, 0.002907434245571494, 0.00015608056855853647, -0.0026470464654266834, -0.004453686065971851, -0.004590773489326239, -0.003011238994076848, -0.00031004135962575674, 0.002499972004443407, 0.0043679228983819485, 0.004597986117005348, 0.003108641365543008, 0.0004614694626070559, -0.0023506300058215857, -0.004275932442396879, -0.004597314167767763, -0.0031994106248021126, -0.0006099619786255062, 0.0021994474809616804, 0.004178009927272797, 0.004588809795677662, 0.003283339086920023, 0.0007551274029538035, -0.0020468549337238073, -0.004074465483427048, -0.004572550766170025, -0.003360242350026965, -0.0008965870947577059, 0.0018932860111817718, 0.003965628333389759, 0.004548639990389347, 0.0034299599938094616, 0.0010339765576645732, -0.0017391747096553445, -0.0038518430665135384, -0.004517205059528351, -0.003492355812340975, -0.001166946836747229, 0.0015849546762183309, 0.0037334668450057507, 0.004478397313505411, 0.0035473189782351255, 0.0012951655080541968, -0.001431056996807456, -0.0036108712665736675, -0.004432390909641981, -0.0035947635769844055, -0.0014183175517246127, 0.0012779090320691466, 0.0034844393376260996, 0.004379383288323879, 0.0036346286069601774, 0.0015361076220870018, -0.0011259327875450253, -0.0033545633777976036, -0.0043195937760174274, -0.003666879143565893, -0.001648259349167347, 0.000975543400272727, 0.0032216450199484825, 0.004253261256963015, 0.0036915054079145193, 0.0017545174341648817, -0.0008271473925560713, -0.0030860919505357742, -0.004180646501481533, -0.003708523465320468, -0.001854648464359343, 0.0006811417988501489, 0.0029483186081051826, 0.004102027975022793, 0.003717973828315735, 0.001948440563865006, -0.0005379121284931898, -0.0028087422251701355, -0.00401770044118166, -0.0037199221551418304, -0.0020357053726911545, 0.00039783157990314066, 0.002667783061042428, 0.003927977290004492, 0.003714458318427205, 0.002116277813911438, -0.000261259323451668, -0.0025258618406951427, -0.003833186812698841, -0.00370169710367918, -0.0021900166757404804, 0.00012853949738200754, 0.0023833992891013622, 0.003733669174835086, 0.0036817756481468678, 0.0022568050771951675, 6.611300189243871e-18, -0.0022408131044358015, -0.0036297801416367292, -0.0036548543721437454, -0.002316551050171256, -0.00012404864537529647, 0.0020985177252441645, 0.003521884558722377, 0.003621115582063794, 0.002369186608120799, 0.0002433142944937572, -0.00195692153647542, -0.0034103572834283113, -0.0035807627718895674, -0.002414669143036008, -0.00035752408439293504, 0.0018164274515584111, 0.0032955820206552744, 0.003534019226208329, 0.002452980726957321, 0.0004664254083763808, -0.0016774289542809129, -0.0031779485289007425, -0.003481128253042698, -0.0024841276463121176, -0.0005697865271940827, 0.0015403105644509196, 0.0030578530859202147, 0.003422351088374853, 0.002508141566067934, 0.0006673974567092955, -0.0014054457424208522, -0.0029356940649449825, -0.0033579657319933176, -0.0025250769685953856, -0.0007590703899040818, 0.0012731956085190177, 0.0028118735644966364, 0.003288266249001026, 0.0025350130163133144, 0.0008446403662674129, -0.0011439077788963914, -0.002686793217435479, -0.003213561372831464, -0.002538051689043641, -0.0009239654755219817, 0.001017915434204042, 0.002560855122283101, 0.003134173573926091, 0.0025343175511807203, 0.000996927497908473, -0.0008955357479862869, -0.0024344578851014376, -0.0030504364985972643, -0.002523957286030054, -0.0010634318459779024, 0.0007770691299811006, 0.002307996852323413, 0.002962695434689522, 0.0025071382988244295, 0.001123407855629921, -0.0006627980037592351, -0.0021818627137690783, -0.002871304051950574, -0.002484048716723919, -0.0011768086114898324, 0.000552986457478255, 0.0020564382430166006, 0.0027766244020313025, 0.002454895991832018, 0.0012236111797392368, -0.0004478787013795227, -0.001932099461555481, -0.0026790250558406115, -0.0024199059698730707, -0.001263816375285387, 0.00034769895137287676, 0.0018092120299115777, 0.0025788790080696344, 0.0023793214932084084, 0.0012974482960999012, -0.0002526503521949053, -0.0016881315968930721, -0.0024765627458691597, -0.002333402168005705, -0.0013245539739727974, 0.0001629147882340476, 0.0015692014712840319, 0.002372455084696412, 0.0022824229672551155, 0.0013452036073431373, -7.865211955504492e-05, -0.0014527522725984454, -0.00226693507283926, -0.00222667190246284, -0.001359489164315164, -1.1134821948207737e-18, 0.0013391001848503947, 0.002160380594432354, 0.002166450023651123, 0.0013675241498276591, 7.292648660950363e-05, -0.0012285460252314806, -0.002053168136626482, -0.0021020700223743916, -0.0013694431399926543, -0.00014003500109538436, 0.001121374312788248, 0.0019456685986369848, 0.002033853903412819, 0.0013654007343575358, 0.00020125597075093538, -0.0010178526863455772, -0.0018382493872195482, -0.001962132751941681, -0.0013555705081671476, -0.00025654269848018885, 0.0009182306239381433]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>plot_width</value></param>
<param><key>value</key><value>900</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rssi_rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rssi_ref</value></param>
<param><key>value</key><value>-91.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(384e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_input</value></param>
<param><key>value</key><value>int(768e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_mpx</value></param>
<param><key>value</key><value>samp_rate /2</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>a_baseband</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq*1000</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>tabs,0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Baseband</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>deemph</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>deemph</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sensitivity</key><value>2*math.pi * (gen_dev / float(samp_rate))</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>2 * math.pi * 4 / (samp_rate / 2)</value></param>
<param><key>max_freq</key><value>2 * math.pi * (19005) / (samp_rate / 2)</value></param>
<param><key>min_freq</key><value>2 * math.pi * (18995) / (samp_rate / 2)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate / (2 * math.pi * (samp_rate * 0.5))</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>axax</value></param>
<param><key>avg_alpha</key><value>0.66</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>tabs,1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>title</key><value>MPX</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win_size</key><value>plot_width,420</value></param>
<param><key>win</key><value>window.flattop</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>19050</value></param>
<param><key>low_cutoff_freq</key><value>18950</value></param>
<param><key>samp_rate</key><value>samp_rate_mpx</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>59000</value></param>
<param><key>low_cutoff_freq</key><value>55000</value></param>
<param><key>samp_rate</key><value>samp_rate_mpx</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>baseband_lpf</value></param>
<param><key>cutoff_freq</key><value>bandwidth * 1000 / 2</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_input</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>comment</key><value>Phase correction</value></param>
<param><key>delay</key><value>51</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/konrad/projects/mpx-power/iq.raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/konrad/projects/mpx-power/mpxpower.raw</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/konrad/projects/mpx-power/deviation.raw</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/konrad/projects/mpx-power/iq.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>samp_rate/rssi_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>int(samp_rate * peak_hold)</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>int(samp_rate / 2 * peak_hold)</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>int(samp_rate / 2 * peak_hold)</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>60</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>2/float(60)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>samp_rate/rssi_rate</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(samp_rate/rssi_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_1</value></param>
<param><key>length</key><value>samp_rate</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(samp_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>samp_rate / float(1000)  / 2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>samp_rate / float(1000)  / 2 / 2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>samp_rate / float(1000)  / 2 / 2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1/float(19)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>num_items</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>num_items</key><value>59</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>int(samp_rate * peak_hold)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>int(samp_rate /2 * peak_hold)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>int(samp_rate /2 * peak_hold)</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate_input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_transcendental</key>
<param><key>id</key><value>blocks_transcendental_0</value></param>
<param><key>name</key><value>sqrt</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_psk_demod</key>
<param><key>id</key><value>digital_psk_demod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate / 2 </value></param>
<param><key>taps</key><value>pilot_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_input</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1_0_0</value></param>
<param><key>center_freq</key><value>57e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_mpx</value></param>
<param><key>taps</key><value>firdes.low_pass(2500.0,250000,2.6e3,2e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gr_rds_decoder</key>
<param><key>id</key><value>gr_rds_decoder_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>gr_rds_panel</key>
<param><key>id</key><value>gr_rds_panel_0</value></param>
<param><key>freq</key><value>freq*1000</value></param>
</block>
<block>
<key>gr_rds_parser</key>
<param><key>id</key><value>gr_rds_parser_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>pty_locale</key><value>0</value></param>
<param><key>reset</key><value>0</value></param>
</block>
<block>
<key>high_pass_filter</key>
<param><key>id</key><value>high_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>30</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>width</key><value>30</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>high_pass_filter</key>
<param><key>id</key><value>high_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>30</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>width</key><value>30</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>samp_rate_mpx / 2 - 1e3</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_2</value></param>
<param><key>cutoff_freq</key><value>16.5e3</value></param>
<param><key>decim</key><value>samp_rate / 2 / samp_rate_audio</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate / 2 </value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_2_0</value></param>
<param><key>cutoff_freq</key><value>16.5e3</value></param>
<param><key>decim</key><value>samp_rate / 2 / samp_rate_audio</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate / 2 </value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq*1000-freq_offset</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>airspyhf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_input</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>19000/float(samp_rate_mpx)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>100</value></param>
<param><key>samp_rate</key><value>19000</value></param>
<param><key>sym_rate</key><value>2375</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>tabs</value></param>
<param><key>labels</key><value>['Baseband', 'MPX', 'L+R', 'L-R', 'L', 'R', 'Other']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>MPX_Full</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>L</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_1</value></param>
<param><key>stream_id</key><value>L+R</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>N</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>Pilot</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_2</value></param>
<param><key>stream_id</key><value>RSSI</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>Dev_Peak</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>Dev_RMS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_1</value></param>
<param><key>stream_id</key><value>Dev_Pilot</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_1_0</value></param>
<param><key>stream_id</key><value>Dev_RDS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>MPX_Power</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>RDS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>Baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>Pilot</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_1</value></param>
<param><key>stream_id</key><value>L+R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_1_0</value></param>
<param><key>stream_id</key><value>L</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>MPX_Full</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_10</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_11</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_12</value></param>
<param><key>stream_id</key><value>RDS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_13</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>Dev_Peak</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_13_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>MPX_Power</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>Dev_RMS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>Dev_Peak</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>Dev_Pilot</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0_0</value></param>
<param><key>stream_id</key><value>Dev_RDS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_1</value></param>
<param><key>stream_id</key><value>RSSI</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>MPX_Full</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>Dev_RMS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_6</value></param>
<param><key>stream_id</key><value>MPX_Power</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_7</value></param>
<param><key>stream_id</key><value>Baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_8</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_9</value></param>
<param><key>stream_id</key><value>L+R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_9_0</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_9_0_0</value></param>
<param><key>stream_id</key><value>L</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_9_0_1</value></param>
<param><key>stream_id</key><value>R</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>int(1/peak_hold)</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1/peak_hold</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Deviation (±)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>kHz</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>notebook</key><value>tabs,6</value></param>
<param><key>number_rate</key><value>int(1/peak_hold)</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>RMS deviation (±)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>kHz</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>notebook</key><value>tabs,6</value></param>
<param><key>number_rate</key><value>int(1/peak_hold)</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1/peak_hold</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Pilot peak deviation (±)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>kHz</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_1_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>notebook</key><value>tabs,6</value></param>
<param><key>number_rate</key><value>int(1/peak_hold)</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1/peak_hold</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>RDS peak deviation (±)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>kHz</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_2</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>1</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>80</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>notebook</key><value>tabs,6</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-rssi_ref</value></param>
<param><key>samp_rate</key><value>10</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Signal level</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>dBf</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>12</value></param>
<param><key>min_value</key><value>-12</value></param>
<param><key>number_rate</key><value>1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>MPX Power</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>dBr</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_2</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>tabs,2</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>L+R</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win_size</key><value>plot_width,400</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>tabs,3</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>L-R</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win_size</key><value>plot_width,400</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>tabs,4</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>L</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win_size</key><value>plot_width,400</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_2_0_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>tabs,5</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>R</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win_size</key><value>plot_width,400</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>xxx_0_0</value></param>
<param><key>stream_id</key><value>Baseband</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>baseband_lpf</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>virtual_sink_0_0_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>low_pass_filter_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_transcendental_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0_0</source_block_id><sink_block_id>virtual_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0_0_0</source_block_id><sink_block_id>virtual_sink_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_abs_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_abs_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0</source_block_id><sink_block_id>low_pass_filter_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>virtual_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_max_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>blocks_max_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_transcendental_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>gr_rds_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1_0</source_block_id><sink_block_id>baseband_lpf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_rds_decoder_0</source_block_id><sink_block_id>gr_rds_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gr_rds_parser_0</source_block_id><sink_block_id>gr_rds_panel_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>high_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>high_pass_filter_0_0_0</source_block_id><sink_block_id>blocks_complex_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_2</source_block_id><sink_block_id>high_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_2_0</source_block_id><sink_block_id>high_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_1_0</source_block_id><sink_block_id>analog_fm_deemph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_10</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_10</source_block_id><sink_block_id>band_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_10</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_11</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_12</source_block_id><sink_block_id>digital_psk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_13</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_13_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>wxgui_numbersink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0_0</source_block_id><sink_block_id>wxgui_numbersink2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_1</source_block_id><sink_block_id>wxgui_numbersink2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_6</source_block_id><sink_block_id>wxgui_numbersink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_7</source_block_id><sink_block_id>a_baseband</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_8</source_block_id><sink_block_id>axax</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_9</source_block_id><sink_block_id>wxgui_waterfallsink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_9_0</source_block_id><sink_block_id>wxgui_waterfallsink2_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_9_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_9_0_1</source_block_id><sink_block_id>wxgui_waterfallsink2_2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
